## os/buildroot/package/ntvl/Config.in
```kconfig
config BR2_PACKAGE_NTVL
	bool "ntvl"
	help
	  Layer two peer-to-peer Virtual Private Network. 

	  http://ntvl.bambusoft.mx/
```
